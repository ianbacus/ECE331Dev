# Keil uVision project TIM_KL25Z.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TIM_KL25Z
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group Source Group 1
    ./source/: main.c packetGen.c periph_initialization.c
  group ::Device
    RTE/Device/MKL25Z128xxx4/: startup_MKL25Z4.s system_MKL25Z4.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
